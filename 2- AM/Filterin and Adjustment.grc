options:
  parameters:
    generate_options: qt_gui
    id: ExerciseA
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: resamp_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.10'
    value: '0.05'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:/Users/Studente/Desktop/sogand/4/am_usrp710.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/resamp_factor
    type: float
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HANN
  states: {state: disabled}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_KAISER
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/resamp_factor
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resamp_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0_0_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
